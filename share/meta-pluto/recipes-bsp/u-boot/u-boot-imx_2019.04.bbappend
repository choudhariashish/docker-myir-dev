FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-change-the-CONFIG_SYS_BOOTM_LEN-to-500MB.patch
